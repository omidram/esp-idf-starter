## sdkconfig.defaults
```kconfig
# Wi-Fi Configuration
CONFIG_ESP_WIFI_SSID="Your_SSID"
CONFIG_ESP_WIFI_PASSWORD="Your_PASSWORD"

# Enable OTA
CONFIG_APP_OTA_ENABLED=y
```
